FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = "\
    file://0031-c-conversion-to-base-of-vbase-in-NSDMI-PR80431.patch \
"
